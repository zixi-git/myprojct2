# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=3 OneElfS=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\HARDWARE\LED;..\FREERTOS\include;..\FREERTOS\port;..\HARDWARE\DH11;..\HARDWARE\RTC;..\HARDWARE\MENU;..\HARDWARE\KEY;..\HARDWARE\EEPROM;..\HARDWARE\KEYBOARD;..\HARDWARE\OLED;..\HARDWARE\ESP8266;..\HARDWARE\BEEP;..\HARDWARE\MFRC522;..\HARDWARE\SFM;..\HARDWARE\ESP8266_MQTT;..\HARDWARE\CJSON;..\HARDWARE\MOTOR;..\HARDWARE\jq8900
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/DH11/: dh11.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/EEPROM/: eeprom.c
    ../HARDWARE/KEYBOARD/: keyboard.c
    ../HARDWARE/ESP8266/: esp8266.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/MFRC522/: mfrc522.c
    ../HARDWARE/SFM/: sfm.c
    ../HARDWARE/ESP8266_MQTT/: esp8266_mqtt.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/jq8900/: mp3.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_tim.c
  group FreeRTOS_CORE
    ../FREERTOS/core/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FREERTOS/heap/: heap_4.c
    ../FREERTOS/port/: port.c
